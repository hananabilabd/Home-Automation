# Keil uVision project STM32f103C8_UART-Receiver-I2C-Transmitter.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32f103C8_UART-Receiver-I2C-Transmitter
  c flags: Optim=1
  c define: STD_STDPERIPH_DRIVER
  c include: .\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group Group1
    ./User/: main.c delay.c
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_gpio.c misc.c
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c

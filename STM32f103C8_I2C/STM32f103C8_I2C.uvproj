# Keil uVision project STM32f103C8_I2C.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32f103C8_I2C
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src;.\User;.\STM32F10x_StdPeriph_Driver;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup;..\STM32f103C8_I2C;..\
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group Group1
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_rcc.c
    ./User/: delay.c main.c
